# Keil uVision project STM32_STD.uvprojx, settings and files
target Target (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Template +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER,USE_STM32F10X_HD
  c include: ..\App;..\CMSIS;..\Library\inc;..\User;..\..\..\..\Drive
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group App
    ../App/: function.c sysconf.c
    ../../../../Drive/: fpm_module.c
  group User
    ../User/: main.c stm32f10x_it.c
  group Library
    ../Library/src/: misc.c stm32f10x_gpio.c stm32f10x_usart.c stm32f10x_exti.c stm32f10x_rcc.c
  group CMSIS
    ../CMSIS/: core_cm3.c system_stm32f10x.c
  group Startup
    ../Startup/: startup_stm32f10x_hd.s
